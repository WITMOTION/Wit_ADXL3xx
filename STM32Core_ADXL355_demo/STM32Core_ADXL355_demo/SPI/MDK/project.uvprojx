# Keil uVision project project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Source\APP;..\Source\Drive;..\Source\STM32F10xLib\inc;..\Source\STM32F10xLib\M3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../Source/APP/: Main.c SENSOR.c
  group DRIVER
    ../Source/Drive/: delay.c IO.c IOI2C.c SPI.c UART1.c
  group FWLIB
    ../Source/STM32F10xLib/M3/: stm32f10x_it.c system_stm32f10x.c
    ../Source/STM32F10xLib/startup/: startup_stm32f10x_hd.s
    ../Source/STM32F10xLib/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_usart.c misc.c
